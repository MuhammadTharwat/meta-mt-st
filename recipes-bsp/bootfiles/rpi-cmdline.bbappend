CMDLINE_ROOTFS = ""

# Disable Console on the HDMI
CMDLINE += " vt.global_cursor_default=0"