IMAGE_INSTALL:append = " libgcc libgcc-dev libstdc++-dev libstdc++-staticdev"
IMAGE_INSTALL:append = " iw kea iptables "
IMAGE_INSTALL:append = " i2c-tools"
